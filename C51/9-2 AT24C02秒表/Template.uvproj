# Keil uVision project Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Delayms.c Delayms.h Key.c Key.h LCD1602.c LCD1602.h I2C.c I2C.h AT24C02.c AT24C02.h Timer.c Timer.h Nixie.c Nixie.h
